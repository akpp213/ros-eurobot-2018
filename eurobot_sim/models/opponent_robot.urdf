Commit message: Working single spy

File: eurobot_sim/models/opponent_robot.urdf (robot description, URDF)
Before this commit: robot opponent_robot, 1 links, 0 joints
Links:
- link opponent_robot: geometry visual cylinder length=0.3 radius=0.15
